#include <mega16.h>
#include <delay.h>
#include <stdlib.h>
#include <lcd.h>
unsigned int v, vb,n_p,p_p;
char s[10];
#asm
.equ __lcd_port=0x1B ; PORTA
#endasm
interrupt [6] void ICP1_INT(void)
{#asm
IN   R4,38; 
IN   R5,39; 
#endasm
v= ICR1L  ;
if (PIND.6==1)
{if ( v>vb)  
n_p=v-vb;
else
n_p=1+0xffff-vb+v;
TCCR1B=0B00000010;}
else
{if ( v>vb)  
p_p=v-vb;
else
p_p=1+0xffff-vb+v;
TCCR1B=0B01000010;}
 vb=v; 
}#include <mega16.h>
void main(void){
lcd_init(16);
lcd_clear();
// Prescaler: 8
// Input Capture Interrupt: 0N
TCCR1A=0000000000;
TCCR1B=0B00000010;
TIMSK=0B00100000;
#asm("sei");             
lcd_clear();
delay_ms(1000);
//t=0xffff;
while(1){
ltoa(p_p,s);
lcd_gotoxy(0,0); 
lcd_puts("P=    ") ;   
lcd_gotoxy(2,0);
lcd_puts(s) ;
ltoa(n_p,s); 
lcd_gotoxy(8,0);
lcd_puts("N=    us") ;   
lcd_gotoxy(10,0) ;
lcd_puts(s) ;  
ltoa(n_p+p_p,s); 
lcd_gotoxy(0,1);
lcd_puts("T=      us") ;   
lcd_gotoxy(2,1) ;
lcd_puts(s) ;  
delay_ms(100);
}}

