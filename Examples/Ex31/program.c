#include <mega16.h>#include <mega16.h>
#include <string.h>
#define FOSC 1000000// Clock Speed
#define BAUD 2400
#define MYUBRR FOSC/16/BAUD-1
#define led PORTC.0
char ch,i;
char txt[10];
void USART_Init( unsigned int ubrr)
{UBRRH = (unsigned char)(ubrr>>8);
 UBRRL = (unsigned char)ubrr;
UCSRB = (1<<RXEN)|(1<<TXEN)|(1<<RXCIE);
UCSRC = (1<<URSEL)|(3<<UCSZ0);}
interrupt [12] void usart_tx_isr(void)
{ch=UDR;
if (ch==13) //ch==enter
{
txt[i]=0;
if( strcmp(txt,"led on" )==0)
led=1;
if( strcmp(txt,"led off" )==0)
led=0;
i=0;}
else
{txt[i]=ch;
i++;}
} 
void main(void)
{DDRC.0=1;
USART_Init ( MYUBRR );
#asm("sei");
while(1){}}
